<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\STM8SExamples\stsw-stm8069 std peripheralLib\STM8S_StdPeriph_Lib_V2.1.0\Project\STM8S_StdPeriph_Template\EWSTM8\Project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UniversalBoard.ewp</path>
  </project>
  <batchBuild/>
</workspace>


